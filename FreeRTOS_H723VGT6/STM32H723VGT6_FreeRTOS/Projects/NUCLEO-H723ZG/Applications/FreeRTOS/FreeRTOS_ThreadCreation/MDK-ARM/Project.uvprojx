# Keil uVision project Project.uvprojx, settings and files
target STM32H723ZG_Nucleo_FreeRTOS_ThreadCreation (ARM-ADS)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H723ZG_FreeRTOS +hex (library)
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx
  c include: ..\..\..\..\..\..\Application\Inc;..\..\..\..\..\..\Application\Test\Include;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Drivers\BSP\STM32H7xx_Nucleo\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\STM32H7xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\STM32H7xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\STM32H7xx_HAL_Driver\Inc\Legacy;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\SYSTEM\Include;..\..\..\..\..\..\Middlewares\FreeRTOS\Include;..\..\..\..\..\..\Middlewares\FreeRTOS\CMSIS_RTOS\Include;..\..\..\..\..\..\Middlewares\FreeRTOS\CMSIS_RTOS_V2\Include;..\..\..\..\..\..\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM7
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
    ../Inc/: FreeRTOSConfig.h
  group Application/User
    ../../../../../../Application/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c system_stm32h7xx.c
  group Drivers/BSP/STM32H7xx_Nucleo
    ../../../../../../Drivers/BSP/STM32H7xx_Nucleo/Source/: stm32h7xx_nucleo.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/STM32H7xx/Source/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/CMSIS/Device/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c
  group Middlewares/FreeRTOS/Core
    ../../../../../../Middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/FreeRTOS/CMSIS_RTOS_V2/Source/: cmsis_os2.c
  group Middlewares/FreeRTOS/Port
    ../../../../../../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM7/: port.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.11.0
